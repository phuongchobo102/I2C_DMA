# IAR project STM32F070CB-ELINKGATE.ewp, settings and files
configuration STM32F070CB-ELINKGATE (ARM, debug)
  General.OGChipSelectEditMenu: STM32F070CB ST STM32F070CB
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 34
  General.FPU2: 0
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32F070xB
  ICCARM.CCIncludePath2: ../USB_DEVICE/App; ../USB_DEVICE/Target; ../Core/Inc; ../Drivers/STM32F0xx_HAL_Driver/Inc; ../Drivers/STM32F0xx_HAL_Driver/Inc/Legacy; ../Middlewares/ST/STM32_USB_Device_Library/Core/Inc; ../Middlewares/ST/STM32_USB_Device_Library/Class/CustomHID/Inc; ../Middlewares/lwbtn/Inc; ../Drivers/CMSIS/Device/ST/STM32F0xx/Include; ../Drivers/CMSIS/Include
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: STM32F070CB-ELINKGATE.hex
  ILINK.IlinkOutputFile: STM32F070CB-ELINKGATE.out
  ILINK.IlinkIcfFile: stm32f070xb_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/EWARM
    ./: startup_stm32f070xb.s
  group Application/User/Core
    ../Core/Src/: elinkswitch_gpio.c IS31FL3218.c led.c main.c stm32f0xx_hal_msp.c stm32f0xx_it.c usb_sw_selector.c
  group Application/User/USB_DEVICE/App
    ../USB_DEVICE/App/: usb_device.c usbd_custom_hid_if.c usbd_desc.c
  group Application/User/USB_DEVICE/Target
    ../USB_DEVICE/Target/: usbd_conf.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f0xx.c
  group Drivers/STM32F0xx_HAL_Driver
    ../Drivers/STM32F0xx_HAL_Driver/Src/: stm32f0xx_hal.c stm32f0xx_hal_adc.c stm32f0xx_hal_adc_ex.c stm32f0xx_hal_cortex.c stm32f0xx_hal_dma.c stm32f0xx_hal_exti.c stm32f0xx_hal_flash.c stm32f0xx_hal_flash_ex.c stm32f0xx_hal_gpio.c stm32f0xx_hal_i2c.c stm32f0xx_hal_i2c_ex.c stm32f0xx_hal_pcd.c stm32f0xx_hal_pcd_ex.c stm32f0xx_hal_pwr.c stm32f0xx_hal_pwr_ex.c stm32f0xx_hal_rcc.c stm32f0xx_hal_rcc_ex.c stm32f0xx_hal_spi.c stm32f0xx_hal_spi_ex.c stm32f0xx_hal_tim.c stm32f0xx_hal_tim_ex.c stm32f0xx_hal_uart.c stm32f0xx_hal_uart_ex.c stm32f0xx_ll_usb.c
  group Middlewares/lwbtn
    ../Middlewares/lwbtn/Src/: lwbtn.c
  group Middlewares/USB_Device_Library
    ../Middlewares/ST/STM32_USB_Device_Library/Core/Src/: usbd_core.c usbd_ctlreq.c usbd_ioreq.c
    ../Middlewares/ST/STM32_USB_Device_Library/Class/CustomHID/Src/: usbd_customhid.c
