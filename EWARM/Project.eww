<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\..\..\..\1-YEV\1.HC_5x7\HC_Fast_Rsp\hop_chua.ewp</path>
    </project>
    <batchBuild />
</workspace>
